Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Toilets_Roca_INSPIRA-In-WashR-with-In-tank-Back-to-wa.ifc
Time: 2021-06-04T10:25:38
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: INSPIRA In-Wash® with In-tank - Back to wall single floorstanding Rimless smart toilet
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): INSPIRA In-Wash® with In-tank - Back to wall single floorstanding Rimless smart toilet; SKU (BO_prodsku): 803095xx1; ManufacturName (BO_Manufac): Roca; BrandUrl (BO_brandurl): http://www.roca.com; ProductFamily (BO_prodfam): INSPIRA; ProductGroup (BO_prodgroup): Smart toilet; ManufacturCountry (BO_mancont): Spain; DesignCountry (BO_designcont): Spain; EditionNumber (BO_edinum): 1; Width (BO_width): 385; Height (BO_height): 485; Depth (BO_depth): 585; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/roca/product/803095xx1; ProductDataUrl (BO_prodaturl): bimobject.com/roca/product/803095xx1; ProductUrl (BO_producturl): http://www.export.roca.com/roca-web/catalog-product-detail?codeProduct=803095..1; InstallationInstructions (BO_montins): http://www.export.roca.com/RocaResourceServlet/resources/getMainResource?idObject=%7BA468A818-601B-48CA-9704-E3C687B62CFB%7D; TechnicalDescription (BO_techcert): http://www.export.roca.com/roca-services/productSheet/EX/en/803095..1/; InstructionVideo (BO_youtube): https://www.youtube.com/watch?v=68jtjk-3_i4; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Toilets; BimObjectCategoryCode (BO_bocat_code): sanitary-toilets; IfcClassification (BO_ifcclas): Sanitary Terminal; Uniclass2015Code (BO_uniclass2015_code): Pr_40_20_93_97; Uniclass2015Description (BO_uniclass2015_desc): WC suites; OmniClassCode (BO_omniclass_code): 23-31 19 00; OmniClassDescription (BO_omniclass_name): Toilets; MasterFormat2014Code (BO_masterformat2014_code): 22 41 13.13; MasterFormat2014Description (BO_masterformat2014_name): Residential Water Closets; UniFormat2Code (BO_uniformat2_code): D2010; UniFormat2Description (BO_uniformat2_name): Plumbing Fixtures; RegionEurope (BO_europe): AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA; RegionNorthAmerica (BO_northamerica): AG, AI, AW, BB, BL, BM, BQ, BS, BZ, CA, CR, CU, CW, DM, DO, GD, GL, GP, GT, HN, HT, JM, KN, KY, LC, MF, MQ, MS, MX, NI, PA, PM, PR, SV, SX, TC, TT, US, VC, VG, VI; RegionSouthAmerica (BO_southamerica): AR, BO, BR, CL, CO, EC, FK, GF, GY, PE, PY, SR, UY, VE; RegionMiddleEast (BO_middleeast): AE, AF, BH, EG, IL, IQ, IR, JO, KW, LB, OM, PS, QA, SA, SY, TR, YE; RegionAsia (BO_asia): AM, AZ, BD, BN, BT, CC, CN, CX, GE, HK, ID, IN, IO, JP, KG, KH, KR, KZ, LA, LK, MM, MN, MO, MV, MY, NP, PH, PK, SG, TH, TJ, TM, TW, UZ, VN; RegionOceania (BO_oceania): AS, AU, CK, FJ, FM, GU, KI, MH, MP, NC, NF, NR, NU, NZ, PF, PG, PN, PW, SB, TK, TL, TO, TV, UM, WF, WS, VU; RegionAfrica (BO_africa): AO, BF, BI, BJ, BW, CD, CF, CG, CI, CM, CV, DJ, DZ, EH, ER, ET, GA, GH, GM, GN, GQ, GW, KE, KM, LR, LS, LY, MA, MG, ML, MR, MU, MW, MZ, NA, NE, NG, RE, RW, SC, SD, SH, SL, SN, SO, SS, ST, SZ, TD, TG, TN, TZ, UG, YT, ZA, ZM, ZW
